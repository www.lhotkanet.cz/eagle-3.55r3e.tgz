# EAGLE board demo1r (EAGLE 3.50), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
+5,2V
  Top 0.406: 50.8,80.04 50.8,85.12 52.07,86.39 52.07,91.47 | 35.56,91.47 35.56,86.39 36.83,85.12 SW1. | 71.12,82.58 71.12,91.47 | IC13. 133.35,60.99 132.08,62.26 132.08,94.01 130.81,95.28 127,95.28 127,82.58 | 66.04,14 66.04,16.54 | 74.93,35.59 72.39,35.59 72.39,19.08 71.12,17.81 69.85,17.81 69.85,12.73 | 175.26,33.05 177.8,33.05 177.8,22.89 | 177.8,22.89 179.07,22.89 IC14. | 58.42,26.7 58.42,24.16 58.42,22.89 60.96,22.89 C17. | 146.05,52.1 146.05,11.46 144.78,10.19 140.97,10.19 C16. | 142.24,127.03 148.59,127.03 148.59,144.81 | 177.8,22.89 177.8,8.92 176.53,7.65 167.64,7.65 C21. | 39.37,83.85 39.37,85.12 41.91,85.12 41.91,100.36
  Bottom 0.406: 52.07,91.47 54.61,91.47 | 35.56,91.47 33.02,91.47 | SW1. 39.37,83.85 50.8,83.85 | 71.12,91.47 73.66,91.47 | 50.8,83.85 58.42,83.85 64.77,83.85 66.04,82.58 ST1. 71.12,82.58 SS1. 99.06,82.58 SS2. 127,82.58 SS3. 154.94,82.58 SS4. 182.88,82.58 | 50.8,83.85 50.8,80.04 | 68.58,12.73 69.85,12.73 | 68.58,12.73 67.31,14 66.04,14 | 66.04,16.54 82.55,16.54 | 33.02,38.13 33.02,34.32 68.58,34.32 69.85,35.59 74.93,35.59 80.01,35.59 81.28,34.32 105.41,34.32 106.68,33.05 119.38,33.05 | 80.01,100.36 IC11. 60.96,100.36 IC10. 41.91,100.36 IC9. 22.86,100.36 IC8. 3.81,100.36 | 86.36,127.03 99.06,127.03 100.33,128.3 104.14,128.3 105.41,127.03 114.3,127.03 127,127.03 128.27,128.3 132.08,128.3 133.35,127.03 142.24,127.03 147.32,127.03 148.59,128.3 158.75,128.3 160.02,127.03 170.18,127.03 | 181.61,19.08 180.34,19.08 180.34,21.62 IC14. | 44.45,29.24 55.88,29.24 57.15,27.97 57.15,26.7 58.42,26.7 | 16.51,91.47 13.97,91.47 12.7,91.47 12.7,90.2 3.81,90.2 | 3.81,30.51 7.62,30.51 | 3.81,67.34 7.62,67.34 | 20.32,71.15 20.32,68.61 3.81,68.61 | 52.07,11.46 IC16. | 50.8,12.73 54.61,12.73 68.58,12.73 | 3.81,78.77 IC15.
  Bottom 1.27: 177.8,144.81 148.59,144.81 120.65,144.81 93.98,144.81 71.12,144.81 59.69,144.81 27.94,144.81 16.51,144.81 13.97,144.81 7.62,138.46 3.81,138.46 3.81,100.36 3.81,90.2 3.81,78.77 3.81,68.61 3.81,67.34 3.81,30.51 3.81,12.73 50.8,12.73 52.07,11.46 58.42,5.11 C17. C19. C16. C21.
+12V
  Bottom 0.406: 39.37,73.69 36.83,73.69 35.56,73.69 35.56,69.88 53.34,69.88 54.61,68.61 73.66,68.61 | 71.12,69.88 72.39,69.88 73.66,68.61 | 73.66,68.61 97.79,68.61 97.79,69.88 99.06,69.88 100.33,69.88 101.6,68.61 125.73,68.61 127,69.88 128.27,69.88 129.54,68.61 153.67,68.61 154.94,69.88 156.21,69.88 157.48,68.61 181.61,68.61 182.88,69.88
-12V
  Bottom 0.406: 36.83,71.15 39.37,71.15 53.34,71.15 54.61,69.88 68.58,69.88 69.85,71.15 72.39,71.15 73.66,69.88 96.52,69.88 97.79,71.15 100.33,71.15 101.6,69.88 124.46,69.88 125.73,71.15 128.27,71.15 129.54,69.88 152.4,69.88 153.67,71.15 156.21,71.15 157.48,69.88 180.34,69.88
A0  (via drill 0.61 pad 1.02)
  Top 0.406: 104.14,25.43 104.14,26.7 97.79,26.7 96.52,27.97 v96.52,49.56 96.52,64.8 95.25,66.07 95.25,132.11 97.79,132.11 v97.79,123.22 99.06,121.95 99.06,104.17 100.33,102.9 101.6,102.9 101.6,101.63
  Bottom 0.406: 33.02,53.37 34.29,53.37 34.29,52.1 35.56,50.83 74.93,50.83 87.63,50.83 88.9,49.56 v96.52,49.56 | 104.14,25.43 116.84,25.43 118.11,24.16 144.78,24.16 146.05,25.43 160.02,25.43 | 22.86,123.22 24.13,123.22 25.4,121.95 39.37,121.95 | 39.37,121.95 40.64,123.22 41.91,123.22 | 39.37,121.95 58.42,121.95 59.69,123.22 60.96,123.22 62.23,123.22 63.5,121.95 73.66,121.95 74.93,123.22 80.01,123.22 v97.79,123.22 | 101.6,101.63 111.76,101.63 113.03,102.9 119.38,102.9 120.65,101.63 129.54,101.63 138.43,101.63 139.7,102.9 151.13,102.9 152.4,101.63 157.48,101.63 166.37,101.63 167.64,102.9 179.07,102.9 180.34,101.63 185.42,101.63
A1  (via drill 0.61 pad 1.02)
  Top 0.406: 72.39,48.29 71.12,48.29 v71.12,27.97 | 72.39,48.29 74.93,48.29 | 72.39,48.29 72.39,63.53 74.93,63.53 74.93,87.66 76.2,88.93 80.01,88.93 80.01,96.55 78.74,97.82 76.2,97.82 76.2,119.41 77.47,120.68 80.01,120.68
  Bottom 0.406: 30.48,53.37 30.48,48.29 74.93,48.29 | 160.02,27.97 158.75,27.97 157.48,26.7 118.11,26.7 116.84,27.97 104.14,27.97 96.52,27.97 95.25,26.7 72.39,26.7 v71.12,27.97 | 22.86,120.68 24.13,120.68 25.4,119.41 27.94,119.41 29.21,120.68 41.91,120.68 43.18,120.68 44.45,119.41 46.99,119.41 48.26,120.68 60.96,120.68 62.23,120.68 63.5,119.41 66.04,119.41 67.31,120.68 80.01,120.68 81.28,120.68 81.28,118.14 82.55,118.14 83.82,116.87 83.82,105.44 95.25,105.44 96.52,104.17 101.6,104.17 111.76,104.17 113.03,105.44 123.19,105.44 124.46,104.17 129.54,104.17 139.7,104.17 140.97,105.44 151.13,105.44 152.4,104.17 157.48,104.17 167.64,104.17 168.91,105.44 179.07,105.44 180.34,104.17 185.42,104.17
A2
  Top 0.406: 27.94,53.37 27.94,62.26 29.21,63.53 29.21,92.74 31.75,92.74 31.75,115.6 30.48,116.87 22.86,116.87 22.86,118.14
  Bottom 0.406: 80.01,118.14 71.12,118.14 69.85,116.87 63.5,116.87 62.23,118.14 60.96,118.14 59.69,118.14 58.42,116.87 44.45,116.87 43.18,118.14 41.91,118.14 29.21,118.14 27.94,116.87 25.4,116.87 24.13,118.14 22.86,118.14
A3
  Top 0.406: 25.4,53.37 25.4,62.26 26.67,63.53 27.94,63.53 27.94,104.17 24.13,104.17 24.13,114.33 22.86,114.33 22.86,115.6
  Bottom 0.406: 80.01,115.6 71.12,115.6 69.85,114.33 63.5,114.33 62.23,115.6 60.96,115.6 59.69,115.6 58.42,114.33 44.45,114.33 43.18,115.6 41.91,115.6 40.64,115.6 39.37,114.33 25.4,114.33 24.13,115.6 22.86,115.6
A4  (via drill 0.61 pad 1.02)
  Top 0.406: 22.86,53.37 22.86,52.1 34.29,52.1 34.29,105.44 39.37,105.44 39.37,110.52 40.64,111.79 41.91,111.79 41.91,113.06 | 133.35,52.1 133.35,57.18 134.62,58.45 v134.62,88.93 | v82.55,88.93 82.55,110.52 81.28,111.79 80.01,111.79 80.01,113.06
  Bottom 0.406: 22.86,113.06 24.13,113.06 25.4,111.79 39.37,111.79 40.64,113.06 41.91,113.06 43.18,113.06 44.45,111.79 58.42,111.79 59.69,113.06 60.96,113.06 62.23,113.06 63.5,111.79 73.66,111.79 74.93,113.06 80.01,113.06 | v82.55,88.93 v134.62,88.93
A5  (via drill 0.61 pad 1.02)
  Top 0.406: 20.32,53.37 20.32,68.61 19.05,69.88 19.05,88.93 17.78,90.2 v17.78,110.52 | v135.89,47.02 135.89,52.1
  Bottom 0.406: 80.01,110.52 67.31,110.52 66.04,109.25 63.5,109.25 62.23,110.52 60.96,110.52 59.69,110.52 58.42,109.25 44.45,109.25 43.18,110.52 41.91,110.52 40.64,110.52 39.37,109.25 25.4,109.25 24.13,110.52 22.86,110.52 v17.78,110.52 | v135.89,47.02 24.13,47.02 22.86,48.29 22.86,52.1 21.59,52.1 21.59,53.37 20.32,53.37
A6  (via drill 0.61 pad 1.02)
  Top 0.406: v24.13,55.91 24.13,97.82 22.86,99.09 21.59,99.09 21.59,106.71 22.86,106.71 22.86,107.98
  Bottom 0.406: 41.91,107.98 43.18,107.98 44.45,106.71 | 44.45,106.71 58.42,106.71 59.69,107.98 60.96,107.98 62.23,107.98 63.5,106.71 66.04,106.71 67.31,107.98 80.01,107.98 | 17.78,53.37 17.78,55.91 v24.13,55.91 41.91,55.91 41.91,52.1 92.71,52.1 92.71,53.37 93.98,54.64 138.43,54.64 138.43,52.1 | 44.45,106.71 25.4,106.71 24.13,107.98 22.86,107.98
A7  (via drill 0.61 pad 1.02)
  Top 0.406: 15.24,53.37 15.24,68.61 13.97,69.88 13.97,88.93 15.24,90.2 v15.24,105.44
  Bottom 0.406: v15.24,105.44 22.86,105.44 24.13,105.44 25.4,104.17 27.94,104.17 29.21,105.44 41.91,105.44 43.18,105.44 44.45,104.17 46.99,104.17 48.26,105.44 60.96,105.44 62.23,105.44 63.5,104.17 66.04,104.17 67.31,105.44 80.01,105.44
A8  (via drill 0.61 pad 1.02)
  Top 0.406: v6.35,54.64 5.08,55.91 5.08,105.44 6.35,106.71 7.62,106.71 7.62,107.98
  Bottom 0.406: 64.77,107.98 63.5,107.98 62.23,109.25 59.69,109.25 58.42,107.98 45.72,107.98 44.45,107.98 43.18,109.25 40.64,109.25 39.37,107.98 26.67,107.98 25.4,107.98 24.13,109.25 13.97,109.25 12.7,107.98 7.62,107.98 | 12.7,53.37 11.43,52.1 8.89,52.1 8.89,54.64 v6.35,54.64
A9  (via drill 0.61 pad 1.02)
  Top 0.406: v7.62,55.91 7.62,64.8 6.35,66.07 6.35,104.17 8.89,104.17 8.89,109.25 7.62,109.25 7.62,110.52
  Bottom 0.406: 64.77,110.52 63.5,110.52 62.23,111.79 59.69,111.79 58.42,110.52 45.72,110.52 44.45,110.52 43.18,111.79 40.64,111.79 39.37,110.52 26.67,110.52 25.4,110.52 24.13,111.79 13.97,111.79 12.7,110.52 7.62,110.52 | 10.16,53.37 10.16,55.91 v7.62,55.91
A10  (via drill 0.61 pad 1.02)
  Top 0.406: v21.59,50.83 21.59,97.82 20.32,99.09 20.32,118.14 21.59,119.41 26.67,119.41 26.67,118.14
  Bottom 0.406: 64.77,118.14 63.5,118.14 62.23,119.41 59.69,119.41 58.42,118.14 45.72,118.14 44.45,118.14 43.18,119.41 29.21,119.41 27.94,118.14 26.67,118.14 25.4,118.14 24.13,119.41 21.59,119.41 20.32,118.14 7.62,118.14 | IC12. 7.62,50.83 v21.59,50.83
A11
  Top 0.406: 7.62,38.13 7.62,39.4 3.81,39.4 3.81,110.52 5.08,111.79 7.62,111.79 7.62,113.06
  Bottom 0.406: 64.77,113.06 63.5,113.06 62.23,114.33 59.69,114.33 58.42,113.06 45.72,113.06 44.45,113.06 43.18,114.33 40.64,114.33 39.37,113.06 26.67,113.06 25.4,113.06 24.13,114.33 13.97,114.33 12.7,113.06 7.62,113.06
A12  (via drill 0.61 pad 1.02)
  Top 0.406: 10.16,38.13 10.16,50.83 11.43,52.1 v11.43,64.8 | v26.67,64.8 26.67,97.82 25.4,99.09 25.4,100.36 24.13,101.63 22.86,101.63 22.86,102.9
  Bottom 0.406: v11.43,64.8 v26.67,64.8 | 22.86,102.9 24.13,102.9 25.4,101.63 27.94,101.63 29.21,102.9 41.91,102.9 43.18,102.9 44.45,101.63 46.99,101.63 48.26,102.9 60.96,102.9 62.23,102.9 63.5,101.63 66.04,101.63 67.31,102.9 80.01,102.9
A13  (via drill 0.61 pad 1.02)
  Top 0.406: v30.48,57.18 30.48,91.47
  Bottom 0.406: 50.8,90.2 49.53,91.47 | 50.8,90.2 62.23,90.2 63.5,91.47 68.58,91.47 | 12.7,38.13 12.7,49.56 6.35,49.56 5.08,50.83 5.08,57.18 v30.48,57.18 | 11.43,91.47 12.7,92.74 24.13,92.74 25.4,91.47 30.48,91.47 31.75,91.47 31.75,90.2 50.8,90.2
A13_1  (via drill 0.61 pad 1.02)
  Top 0.406: 11.43,94.01 v11.43,105.44
  Bottom 0.406: 11.43,94.01 13.97,94.01 | v11.43,105.44 7.62,105.44
A13_2
  Top 0.406: 26.67,105.44 30.48,105.44 30.48,94.01
  Bottom 0.406: 30.48,94.01 33.02,94.01
A13_3
  Top 0.406: 45.72,105.44 49.53,105.44 49.53,94.01
  Bottom 0.406: 49.53,94.01 52.07,94.01
A13_4
  Top 0.406: 64.77,105.44 67.31,105.44 67.31,95.28 68.58,95.28 68.58,94.01
  Bottom 0.406: 68.58,94.01 71.12,94.01
A14
  Top 0.406: 15.24,38.13 15.24,50.83 13.97,52.1 13.97,67.34 12.7,68.61 7.62,68.61 7.62,71.15
A15  (via drill 0.61 pad 1.02)
  Top 0.406: 17.78,38.13 17.78,50.83 16.51,52.1 v16.51,69.88
  Bottom 0.406: v16.51,69.88 11.43,69.88 11.43,71.15 10.16,71.15
ARDY1  (via drill 0.61 pad 1.02)
  Top 0.406: v107.95,135.92 107.95,132.11 109.22,132.11 109.22,130.84
  Bottom 0.406: 101.6,134.65 104.14,134.65 105.41,135.92 v107.95,135.92
ARDY2
  Bottom 0.406: 129.54,134.65 135.89,134.65 135.89,130.84 137.16,130.84
ARDY3
  Bottom 0.406: 157.48,134.65 163.83,134.65 163.83,130.84 165.1,130.84
ARDY4
  Bottom 0.406: 185.42,134.65 191.77,134.65 191.77,130.84 193.04,130.84
ASTB2
  Top 0.406: 129.54,129.57 137.16,129.57 137.16,128.3
ASTB3
  Top 0.406: 157.48,129.57 165.1,129.57 165.1,128.3
ASTB4
  Bottom 0.406: 185.42,129.57 191.77,129.57 191.77,128.3 193.04,128.3
ATSB1
  Top 0.406: 101.6,129.57 109.22,129.57 109.22,128.3
BRDY1
  Top 0.406: 86.36,139.73 86.36,141 105.41,141 105.41,132.11 106.68,132.11 106.68,130.84
BRDY2
  Top 0.406: 134.62,130.84 132.08,130.84 132.08,139.73 130.81,141 114.3,141 114.3,139.73
BRDY3  (via drill 0.61 pad 1.02)
  Top 0.406: v161.29,138.46 161.29,132.11 162.56,132.11 162.56,130.84
  Bottom 0.406: 142.24,139.73 151.13,139.73 152.4,138.46 v161.29,138.46
BRDY4
  Bottom 0.406: 170.18,139.73 179.07,139.73 180.34,138.46 186.69,138.46 186.69,135.92 184.15,135.92 184.15,133.38 186.69,133.38 187.96,132.11 187.96,130.84 190.5,130.84
BSTB1
  Top 0.406: 101.6,132.11 100.33,130.84 100.33,128.3 106.68,128.3
BSTB2
  Top 0.406: 129.54,132.11 128.27,130.84 128.27,128.3 134.62,128.3
BSTB3
  Top 0.406: 157.48,132.11 156.21,130.84 156.21,128.3 162.56,128.3
BSTB4
  Bottom 0.406: 185.42,132.11 184.15,132.11 184.15,128.3 190.5,128.3
BUSRQ  (via drill 0.61 pad 1.02)
  Top 0.406: 31.75,29.24 v31.75,45.75 | v45.72,45.75 45.72,53.37
  Bottom 0.406: v31.75,45.75 v45.72,45.75
CI1
  Top 0.406: 186.69,29.24 186.69,31.78 186.69,33.05 184.15,33.05 184.15,52.1 182.88,53.37 Q1. | 193.04,55.91 R2.
  Bottom 0.406: Q1. 193.04,55.91
CI2
  Bottom 0.406: 179.07,24.16 180.34,24.16 180.34,34.32 186.69,34.32
CI3
  Top 0.406: 179.07,26.7 179.07,29.24
CI4
  Top 0.406: 179.07,31.78 179.07,34.32
CI5
  Top 0.406: 182.88,50.83 182.88,24.16 184.15,22.89 186.69,22.89 186.69,21.62 | 193.04,22.89 193.04,20.35
  Bottom 0.406: 186.69,21.62 190.5,21.62 191.77,22.89 193.04,22.89
CI6
  Top 0.406: 186.69,24.16 193.04,24.16 R1. 193.04,35.59
CI7
  Top 0.406: 186.69,26.7 190.5,26.7 190.5,38.13 191.77,39.4 193.04,39.4 | 193.04,39.4 193.04,38.13 | 193.04,39.4 C2.
CK  (via drill 0.61 pad 1.02)
  Top 0.406: 24.13,29.24 24.13,31.78 21.59,31.78 20.32,33.05 20.32,38.13 20.32,50.83 19.05,52.1 v19.05,58.45 | v179.07,58.45 179.07,36.86 | 170.18,129.57 175.26,129.57 175.26,58.45
  Bottom 0.406: 86.36,129.57 99.06,129.57 100.33,130.84 104.14,130.84 105.41,129.57 114.3,129.57 119.38,129.57 120.65,130.84 130.81,130.84 132.08,129.57 142.24,129.57 147.32,129.57 148.59,130.84 158.75,130.84 160.02,129.57 170.18,129.57 | v179.07,58.45 175.26,58.45 162.56,58.45 161.29,59.72 153.67,59.72 152.4,58.45 119.38,58.45 114.3,58.45 113.03,59.72 88.9,59.72 87.63,58.45 74.93,58.45 v19.05,58.45
CLK/TRG0  (via drill 0.61 pad 1.02)
  Top 0.406: 74.93,38.13 73.66,39.4 73.66,47.02 76.2,47.02 v76.2,73.69
  Bottom 0.406: v76.2,73.69 69.85,73.69 69.85,74.96 68.58,74.96
CLK/TRG1  (via drill 0.61 pad 1.02)
  Top 0.406: 74.93,40.67 76.2,41.94 76.2,43.21 77.47,44.48 v77.47,74.96
  Bottom 0.406: v77.47,74.96 71.12,74.96
CLK/TRG2  (via drill 0.61 pad 1.02)
  Top 0.406: v66.04,43.21 66.04,69.88 67.31,71.15 68.58,71.15 68.58,72.42
  Bottom 0.406: v66.04,43.21 74.93,43.21
CLK/TRG3  (via drill 0.61 pad 1.02)
  Top 0.406: v69.85,45.75 69.85,71.15 71.12,71.15 71.12,72.42
  Bottom 0.406: v69.85,45.75 74.93,45.75
CTSA1  (via drill 0.61 pad 1.02)
  Top 0.406: v121.92,53.37 v121.92,72.42
  Bottom 0.406: 119.38,53.37 v121.92,53.37 | v121.92,72.42 124.46,72.42
CTSA2
  Top 0.406: 175.26,53.37 177.8,53.37 177.8,69.88 179.07,71.15 180.34,71.15 180.34,72.42
CTSB1  (via drill 0.61 pad 1.02)
  Top 0.406: 104.14,53.37 102.87,54.64 v102.87,73.69
  Bottom 0.406: v102.87,73.69 97.79,73.69 97.79,72.42 96.52,72.42
CTSB2
  Top 0.406: 160.02,53.37 158.75,54.64 158.75,74.96 157.48,76.23 151.13,76.23 151.13,72.42 152.4,72.42
D0  (via drill 0.61 pad 1.02)
  Top 0.406: v72.39,38.13 73.66,36.86 76.2,36.86 | 76.2,36.86 76.2,34.32 74.93,34.32 74.93,33.05 | v106.68,31.78 106.68,12.73 105.41,11.46 104.14,11.46 IC7. | v78.74,135.92 78.74,127.03 80.01,125.76 80.01,124.49 81.28,124.49 81.28,119.41 78.74,119.41 77.47,118.14 77.47,99.09 80.01,99.09 81.28,97.82 81.28,62.26 78.74,62.26 78.74,40.67 76.2,40.67 76.2,36.86
  Bottom 0.406: 40.64,38.13 41.91,39.4 71.12,39.4 v72.39,38.13 | IC7. 113.03,10.19 114.3,8.92 157.48,8.92 158.75,10.19 IC6. | 74.93,33.05 87.63,33.05 88.9,31.78 v106.68,31.78 | 22.86,125.76 24.13,125.76 25.4,124.49 39.37,124.49 40.64,125.76 41.91,125.76 43.18,125.76 44.45,124.49 58.42,124.49 59.69,125.76 60.96,125.76 62.23,125.76 63.5,124.49 73.66,124.49 74.93,125.76 80.01,125.76 | 185.42,137.19 180.34,137.19 179.07,138.46 168.91,138.46 167.64,137.19 157.48,137.19 152.4,137.19 151.13,138.46 140.97,138.46 139.7,137.19 129.54,137.19 124.46,137.19 123.19,138.46 113.03,138.46 111.76,137.19 101.6,137.19 96.52,137.19 95.25,135.92 v78.74,135.92
D1  (via drill 0.61 pad 1.02)
  Top 0.406: v43.18,33.05 43.18,38.13 | 74.93,30.51 73.66,29.24 v73.66,11.46 | 83.82,128.3 80.01,128.3 | 83.82,128.3 83.82,137.19 85.09,138.46 101.6,138.46 101.6,139.73 | v82.55,30.51 82.55,85.12 83.82,86.39 83.82,128.3
  Bottom 0.406: v43.18,33.05 71.12,33.05 71.12,30.51 74.93,30.51 v82.55,30.51 | 175.26,10.19 170.18,10.19 168.91,11.46 158.75,11.46 157.48,10.19 119.38,10.19 114.3,10.19 113.03,11.46 v73.66,11.46 | 22.86,128.3 24.13,128.3 25.4,127.03 39.37,127.03 40.64,128.3 41.91,128.3 43.18,128.3 44.45,127.03 58.42,127.03 59.69,128.3 60.96,128.3 62.23,128.3 63.5,127.03 73.66,127.03 74.93,128.3 80.01,128.3 | 101.6,139.73 111.76,139.73 113.03,141 123.19,141 124.46,139.73 129.54,139.73 139.7,139.73 140.97,141 151.13,141 152.4,139.73 157.48,139.73 167.64,139.73 168.91,141 179.07,141 180.34,139.73 185.42,139.73
D2  (via drill 0.61 pad 1.02)
  Top 0.406: 76.2,26.7 74.93,27.97 | v76.2,12.73 76.2,26.7 | v77.47,39.4 77.47,27.97 76.2,26.7 | v96.52,130.84 96.52,94.01 97.79,92.74 101.6,92.74 101.6,91.47 | v125.73,11.46 125.73,73.69 128.27,73.69 128.27,76.23 129.54,77.5 129.54,91.47
  Bottom 0.406: v76.2,12.73 104.14,12.73 116.84,12.73 118.11,11.46 v125.73,11.46 157.48,11.46 158.75,12.73 160.02,12.73 | 35.56,38.13 35.56,40.67 72.39,40.67 73.66,39.4 v77.47,39.4 | 22.86,130.84 24.13,130.84 25.4,129.57 39.37,129.57 40.64,130.84 41.91,130.84 43.18,130.84 44.45,129.57 58.42,129.57 59.69,130.84 60.96,130.84 62.23,130.84 63.5,129.57 73.66,129.57 74.93,130.84 80.01,130.84 v96.52,130.84 | 101.6,91.47 111.76,91.47 113.03,92.74 119.38,92.74 120.65,91.47 129.54,91.47 139.7,91.47 140.97,92.74 144.78,92.74 146.05,91.47 157.48,91.47 167.64,91.47 168.91,92.74 179.07,92.74 180.34,91.47 185.42,91.47
D3  (via drill 0.61 pad 1.02)
  Top 0.406: v74.93,14 IC5. | 25.4,38.13 25.4,16.54 26.67,15.27 v27.94,15.27 | 64.77,133.38 62.23,133.38 v62.23,92.74 | 119.38,12.73 113.03,12.73 113.03,85.12 114.3,86.39 IC3.
  Bottom 0.406: v27.94,15.27 73.66,15.27 v74.93,14 116.84,14 118.11,12.73 119.38,12.73 157.48,12.73 158.75,14 161.29,14 162.56,12.73 175.26,12.73 | 7.62,133.38 20.32,133.38 21.59,134.65 24.13,134.65 | 24.13,134.65 25.4,133.38 26.67,133.38 | 64.77,133.38 63.5,133.38 62.23,134.65 59.69,134.65 58.42,133.38 45.72,133.38 44.45,133.38 43.18,134.65 24.13,134.65 | IC2. 140.97,91.47 139.7,90.2 | 139.7,90.2 120.65,90.2 119.38,91.47 IC3. 113.03,91.47 111.76,90.2 100.33,90.2 99.06,91.47 IC4. 81.28,91.47 80.01,92.74 v62.23,92.74 | IC1. 168.91,91.47 167.64,90.2 139.7,90.2
D4  (via drill 0.61 pad 1.02)
  Top 0.406: 104.14,15.27 90.17,15.27 90.17,25.43 | 64.77,130.84 74.93,130.84 74.93,97.82 76.2,96.55 78.74,96.55 v78.74,94.01 | 160.02,15.27 167.64,15.27 167.64,91.47 168.91,92.74 170.18,92.74 170.18,94.01
  Bottom 0.406: 22.86,38.13 22.86,31.78 29.21,31.78 30.48,30.51 40.64,30.51 40.64,25.43 72.39,25.43 73.66,24.16 83.82,24.16 85.09,25.43 90.17,25.43 | 160.02,15.27 158.75,15.27 157.48,14 118.11,14 116.84,15.27 104.14,15.27 | 7.62,130.84 20.32,130.84 21.59,132.11 24.13,132.11 25.4,130.84 26.67,130.84 39.37,130.84 40.64,132.11 43.18,132.11 44.45,130.84 45.72,130.84 58.42,130.84 59.69,132.11 62.23,132.11 63.5,130.84 64.77,130.84 | 170.18,94.01 168.91,94.01 167.64,92.74 146.05,92.74 144.78,94.01 142.24,94.01 140.97,94.01 139.7,92.74 120.65,92.74 119.38,94.01 114.3,94.01 113.03,94.01 111.76,92.74 100.33,92.74 99.06,94.01 86.36,94.01 v78.74,94.01
D5  (via drill 0.61 pad 1.02)
  Top 0.406: 86.36,96.55 86.36,95.28 85.09,95.28 v85.09,41.94 v85.09,27.97 | 119.38,15.27 115.57,15.27 115.57,95.28 114.3,95.28 114.3,96.55 | 64.77,128.3 71.12,128.3 v71.12,96.55
  Bottom 0.406: 7.62,128.3 20.32,128.3 21.59,129.57 24.13,129.57 25.4,128.3 26.67,128.3 39.37,128.3 40.64,129.57 43.18,129.57 44.45,128.3 45.72,128.3 58.42,128.3 59.69,129.57 62.23,129.57 63.5,128.3 64.77,128.3 | 119.38,15.27 157.48,15.27 158.75,16.54 168.91,16.54 170.18,15.27 175.26,15.27 | 170.18,96.55 168.91,96.55 167.64,95.28 148.59,95.28 147.32,96.55 142.24,96.55 140.97,96.55 139.7,95.28 124.46,95.28 123.19,96.55 114.3,96.55 113.03,96.55 111.76,95.28 100.33,95.28 99.06,96.55 86.36,96.55 v71.12,96.55 | 27.94,38.13 27.94,41.94 v85.09,41.94 | v85.09,27.97 90.17,27.97
D6  (via drill 0.61 pad 1.02)
  Top 0.406: 90.17,30.51 92.71,30.51 92.71,24.16 95.25,24.16 | 95.25,24.16 101.6,24.16 101.6,20.35 102.87,19.08 104.14,19.08 104.14,17.81 | 64.77,125.76 69.85,125.76 v69.85,97.82 | 95.25,24.16 95.25,47.02 93.98,48.29 v93.98,97.82
  Bottom 0.406: 30.48,38.13 30.48,31.78 52.07,31.78 53.34,30.51 67.31,30.51 68.58,29.24 83.82,29.24 85.09,30.51 90.17,30.51 | 160.02,17.81 158.75,17.81 157.48,16.54 110.49,16.54 109.22,17.81 104.14,17.81 | 7.62,125.76 20.32,125.76 21.59,127.03 24.13,127.03 25.4,125.76 26.67,125.76 39.37,125.76 40.64,127.03 43.18,127.03 44.45,125.76 45.72,125.76 58.42,125.76 59.69,127.03 62.23,127.03 63.5,125.76 64.77,125.76 | 185.42,96.55 180.34,96.55 179.07,97.82 168.91,97.82 167.64,96.55 157.48,96.55 152.4,96.55 151.13,97.82 140.97,97.82 139.7,96.55 129.54,96.55 124.46,96.55 123.19,97.82 113.03,97.82 111.76,96.55 101.6,96.55 100.33,96.55 99.06,97.82 v93.98,97.82 v69.85,97.82
D7  (via drill 0.61 pad 1.02)
  Top 0.406: 87.63,33.05 90.17,33.05 | 87.63,33.05 v87.63,19.08 | v38.1,20.35 38.1,38.13 | 64.77,123.22 68.58,123.22 v68.58,96.55 | v87.63,95.28 87.63,33.05
  Bottom 0.406: v38.1,20.35 86.36,20.35 v87.63,19.08 113.03,19.08 114.3,17.81 119.38,17.81 157.48,17.81 158.75,19.08 161.29,19.08 162.56,17.81 175.26,17.81 | 7.62,123.22 20.32,123.22 21.59,124.49 24.13,124.49 25.4,123.22 26.67,123.22 39.37,123.22 40.64,124.49 43.18,124.49 44.45,123.22 45.72,123.22 58.42,123.22 59.69,124.49 62.23,124.49 63.5,123.22 64.77,123.22 | 185.42,94.01 180.34,94.01 179.07,95.28 168.91,95.28 167.64,94.01 157.48,94.01 146.05,94.01 144.78,95.28 140.97,95.28 139.7,94.01 129.54,94.01 124.46,94.01 123.19,95.28 113.03,95.28 111.76,94.01 101.6,94.01 100.33,94.01 99.06,95.28 v87.63,95.28 69.85,95.28 v68.58,96.55
DCDA1  (via drill 0.61 pad 1.02)
  Top 0.406: v129.54,55.91 v129.54,74.96
  Bottom 0.406: 119.38,55.91 v129.54,55.91 | v129.54,74.96 127,74.96
DCDA2  (via drill 0.61 pad 1.02)
  Top 0.406: 175.26,55.91 176.53,57.18 v176.53,73.69
  Bottom 0.406: v176.53,73.69 181.61,73.69 181.61,74.96 182.88,74.96
DCDB1  (via drill 0.61 pad 1.02)
  Top 0.406: v101.6,55.91 101.6,72.42 100.33,73.69 99.06,73.69 99.06,74.96
  Bottom 0.406: v101.6,55.91 104.14,55.91
DCDB2  (via drill 0.61 pad 1.02)
  Top 0.406: v157.48,55.91 157.48,72.42 156.21,73.69 154.94,73.69 154.94,74.96
  Bottom 0.406: v157.48,55.91 160.02,55.91
DOG
  Top 0.406: 17.78,16.54 22.86,16.54 D1. | 39.37,76.23 40.64,74.96 40.64,64.8 39.37,64.8 39.37,29.24
  Bottom 0.406: 39.37,76.23 36.83,76.23 | 39.37,29.24 39.37,22.89 D1.
DTRA1  (via drill 0.61 pad 1.02)
  Top 0.406: v123.19,48.29 123.19,73.69 124.46,73.69 124.46,74.96
  Bottom 0.406: 119.38,48.29 v123.19,48.29
DTRA2  (via drill 0.61 pad 1.02)
  Top 0.406: 175.26,48.29 172.72,48.29 v172.72,74.96
  Bottom 0.406: v172.72,74.96 180.34,74.96
DTRB1
  Top 0.406: 104.14,48.29 97.79,48.29 97.79,73.69 96.52,73.69 96.52,74.96
DTRB2
  Top 0.406: 160.02,48.29 153.67,48.29 153.67,73.69 152.4,73.69 152.4,74.96
GND
  Top 0.406: C14. 10.16,35.59 8.89,36.86 8.89,60.99 10.16,62.26 C15. | 39.37,66.07 39.37,68.61 | 35.56,53.37 35.56,62.26 36.83,63.53 36.83,66.07 36.83,68.61 | 66.04,29.24 66.04,40.67 67.31,41.94 67.31,60.99 68.58,62.26 68.58,67.34 | C18. 85.09,17.81 88.9,17.81 88.9,31.78 91.44,31.78 91.44,34.32 90.17,34.32 90.17,35.59 | 152.4,67.34 152.4,58.45 151.13,57.18 151.13,52.1 151.13,35.59 160.02,35.59 | 60.96,133.38 60.96,146.08 59.69,146.08 C8.
  Bottom 0.406: 12.7,71.15 13.97,72.42 24.13,72.42 24.13,71.15 25.4,71.15 26.67,71.15 26.67,68.61 | 39.37,68.61 36.83,68.61 26.67,68.61 | C22. 54.61,60.99 53.34,62.26 39.37,62.26 39.37,64.8 38.1,66.07 36.83,66.07 | C15. 25.4,67.34 26.67,68.61 | 39.37,66.07 44.45,66.07 45.72,67.34 50.8,67.34 68.58,67.34 71.12,67.34 96.52,67.34 99.06,67.34 124.46,67.34 127,67.34 152.4,67.34 154.94,67.34 180.34,67.34 182.88,67.34 196.85,67.34 | 90.17,35.59 104.14,35.59 116.84,35.59 118.11,36.86 153.67,36.86 154.94,35.59 160.02,35.59 | 101.6,116.87 111.76,116.87 113.03,115.6 123.19,115.6 124.46,116.87 129.54,116.87 139.7,116.87 140.97,115.6 151.13,115.6 152.4,116.87 157.48,116.87 167.64,116.87 168.91,115.6 179.07,115.6 180.34,116.87 185.42,116.87 196.85,116.87 | 22.86,133.38 24.13,133.38 25.4,132.11 39.37,132.11 40.64,133.38 41.91,133.38 43.18,133.38 44.45,132.11 58.42,132.11 59.69,133.38 60.96,133.38 62.23,133.38 63.5,132.11 66.04,132.11 67.31,133.38 80.01,133.38 | 196.85,19.08 184.15,19.08 | 196.85,36.86 186.69,36.86 | 196.85,60.99 193.04,60.99
  Bottom 1.27: C6. C7. C8. C9. C10. C11. C12. C13. 185.42,147.35 187.96,144.81 187.96,138.46 189.23,137.19 195.58,137.19 196.85,135.92 196.85,116.87 196.85,67.34 196.85,60.99 196.85,36.86 196.85,19.08 196.85,15.27 193.04,15.27 184.15,15.27 171.45,2.57 167.64,2.57 140.97,2.57 111.76,2.57 60.96,2.57
IEI1  (via drill 0.61 pad 1.02)
  Top 0.406: 41.91,29.24 v41.91,57.18
  Bottom 0.406: v41.91,57.18 83.82,57.18 85.09,55.91 90.17,55.91
IEI2  (via drill 0.61 pad 1.02)
  Top 0.406: 119.38,22.89 124.46,22.89 v124.46,52.1
  Bottom 0.406: v124.46,52.1 96.52,52.1 95.25,50.83 90.17,50.83
IEI3  (via drill 0.61 pad 1.02)
  Top 0.406: v93.98,25.43 93.98,47.02 92.71,48.29 92.71,129.57 91.44,130.84 86.36,130.84 86.36,132.11
  Bottom 0.406: 119.38,25.43 118.11,25.43 116.84,26.7 96.52,26.7 95.25,25.43 v93.98,25.43
IEI4  (via drill 0.61 pad 1.02)
  Top 0.406: v110.49,138.46 111.76,137.19 111.76,134.65 113.03,133.38 114.3,133.38 114.3,132.11
  Bottom 0.406: 86.36,137.19 95.25,137.19 96.52,138.46 v110.49,138.46
IEI5  (via drill 0.61 pad 1.02)
  Top 0.406: v116.84,31.78 116.84,134.65 115.57,135.92 114.3,135.92 114.3,137.19
  Bottom 0.406: 175.26,22.89 176.53,22.89 176.53,31.78 v116.84,31.78
IEI6  (via drill 0.61 pad 1.02)
  Top 0.406: 142.24,132.11 140.97,130.84 140.97,125.76 147.32,125.76 v147.32,24.16
  Bottom 0.406: v147.32,24.16 168.91,24.16 170.18,25.43 175.26,25.43
IEI7
  Top 0.406: 142.24,137.19 147.32,137.19 147.32,146.08 167.64,146.08 167.64,134.65 168.91,133.38 170.18,133.38 170.18,132.11
INT  (via drill 0.61 pad 1.02)
  Top 0.406: v29.21,39.4 29.21,29.24 | 90.17,53.37 91.44,54.64 91.44,127.03 90.17,128.3 85.09,128.3 85.09,133.38 86.36,133.38 86.36,134.65 | v46.99,55.91 46.99,41.94 45.72,40.67 45.72,38.13 v45.72,24.16
  Bottom 0.406: 175.26,20.35 170.18,20.35 168.91,21.62 158.75,21.62 157.48,20.35 119.38,20.35 118.11,20.35 116.84,21.62 68.58,21.62 67.31,22.89 57.15,22.89 55.88,24.16 v45.72,24.16 | 170.18,134.65 167.64,134.65 166.37,135.92 156.21,135.92 154.94,134.65 142.24,134.65 138.43,134.65 137.16,135.92 120.65,135.92 119.38,134.65 114.3,134.65 105.41,134.65 104.14,133.38 100.33,133.38 99.06,134.65 86.36,134.65 | v29.21,39.4 34.29,39.4 34.29,36.86 44.45,36.86 44.45,38.13 45.72,38.13 | v46.99,55.91 72.39,55.91 73.66,54.64 83.82,54.64 85.09,53.37 90.17,53.37
IORQ  (via drill 0.61 pad 1.02)
  Top 0.406: 55.88,38.13 55.88,47.02 54.61,48.29 v54.61,49.56 | 143.51,52.1 143.51,57.18 144.78,58.45 144.78,99.09 143.51,100.36 142.24,100.36 142.24,101.63 | 140.97,52.1 v140.97,19.08
  Bottom 0.406: 104.14,20.35 116.84,20.35 118.11,19.08 v140.97,19.08 157.48,19.08 158.75,20.35 160.02,20.35 | v54.61,49.56 83.82,49.56 85.09,48.29 90.17,48.29 101.6,48.29 102.87,49.56 138.43,49.56 139.7,50.83 139.7,52.1 140.97,52.1 143.51,52.1 | 86.36,101.63 99.06,101.63 100.33,100.36 111.76,100.36 113.03,101.63 114.3,101.63 119.38,101.63 120.65,100.36 138.43,100.36 139.7,101.63 142.24,101.63 151.13,101.63 152.4,100.36 166.37,100.36 167.64,101.63 170.18,101.63
IOSEL0  (via drill 0.61 pad 1.02)
  Top 0.406: v134.62,7.65 134.62,53.37 135.89,54.64 135.89,59.72
  Bottom 0.406: 66.04,11.46 67.31,11.46 67.31,7.65 v134.62,7.65
IOSEL1  (via drill 0.61 pad 1.02)
  Top 0.406: v137.16,22.89 137.16,53.37 138.43,54.64 138.43,59.72
  Bottom 0.406: v137.16,22.89 160.02,22.89
IOSEL2  (via drill 0.61 pad 1.02)
  Top 0.406: v139.7,21.62 139.7,53.37 140.97,54.64 140.97,59.72
  Bottom 0.406: 104.14,22.89 116.84,22.89 118.11,21.62 v139.7,21.62
IOSEL3  (via drill 0.61 pad 1.02)
  Top 0.406: 74.93,55.91 73.66,57.18 v73.66,62.26
  Bottom 0.406: v73.66,62.26 140.97,62.26 142.24,60.99 142.24,59.72 143.51,59.72
IOSEL4  (via drill 0.61 pad 1.02)
  Top 0.406: 101.6,99.09 104.14,99.09 v104.14,85.12 | v146.05,85.12 146.05,59.72
  Bottom 0.406: v104.14,85.12 v146.05,85.12
IOSEL5  (via drill 0.61 pad 1.02)
  Top 0.406: v133.35,63.53 133.35,96.55 132.08,97.82 129.54,97.82 129.54,99.09
  Bottom 0.406: 148.59,59.72 148.59,63.53 v133.35,63.53
IOSEL6
  Top 0.406: 151.13,59.72 151.13,64.8 149.86,66.07 149.86,96.55 151.13,97.82 157.48,97.82 157.48,99.09
IOSEL7  (via drill 0.61 pad 1.02)
  Top 0.406: v186.69,54.64 186.69,97.82 185.42,97.82 185.42,99.09
  Bottom 0.406: 148.59,52.1 148.59,54.64 v186.69,54.64
KEY
  Bottom 0.406: 36.83,81.31 39.37,81.31
M1  (via drill 0.61 pad 1.02)
  Top 0.406: v40.64,63.53 40.64,53.37 | 90.17,58.45 v90.17,63.53 90.17,96.55 88.9,97.82 86.36,97.82 86.36,99.09 | 175.26,27.97 171.45,27.97 171.45,97.82 170.18,97.82 170.18,99.09
  Bottom 0.406: v90.17,63.53 v40.64,63.53 | 119.38,27.97 157.48,27.97 158.75,29.24 168.91,29.24 170.18,27.97 175.26,27.97 | 86.36,99.09 99.06,99.09 100.33,97.82 107.95,97.82 109.22,99.09 114.3,99.09 127,99.09 128.27,97.82 135.89,97.82 137.16,99.09 142.24,99.09 154.94,99.09 156.21,97.82 163.83,97.82 165.1,99.09 170.18,99.09
MEMSEL0
  Top 0.406: 10.16,78.77 10.16,118.14 8.89,119.41 7.62,119.41 7.62,120.68
MEMSEL1
  Top 0.406: 12.7,78.77 12.7,120.68 13.97,121.95 26.67,121.95 26.67,120.68
MEMSEL2  (via drill 0.61 pad 1.02)
  Top 0.406: v44.45,82.58 44.45,119.41 45.72,119.41 45.72,120.68
  Bottom 0.406: 15.24,78.77 15.24,82.58 v44.45,82.58
MEMSEL3  (via drill 0.61 pad 1.02)
  Top 0.406: v63.5,77.5 63.5,119.41 64.77,119.41 64.77,120.68
  Bottom 0.406: 17.78,78.77 19.05,77.5 v63.5,77.5
MREQ  (via drill 0.61 pad 1.02)
  Top 0.406: 53.34,38.13 53.34,50.83 52.07,52.1 v52.07,60.99 | v17.78,60.99 17.78,71.15
  Bottom 0.406: 17.78,71.15 15.24,71.15 | v17.78,60.99 v52.07,60.99
NMI  (via drill 0.61 pad 1.02)
  Top 0.406: 34.29,29.24 v34.29,35.59
  Bottom 0.406: v34.29,35.59 45.72,35.59 46.99,36.86 46.99,38.13 48.26,38.13
PA01
  Top 0.406: 101.6,127.03 109.22,127.03 109.22,125.76
PA02
  Top 0.406: 137.16,125.76 135.89,127.03 129.54,127.03
PA03
  Top 0.406: 157.48,127.03 165.1,127.03 165.1,125.76
PA04
  Bottom 0.406: 185.42,127.03 191.77,127.03 191.77,125.76 193.04,125.76
PA11
  Bottom 0.406: 101.6,124.49 107.95,124.49 107.95,123.22 109.22,123.22
PA12
  Bottom 0.406: 137.16,123.22 135.89,124.49 129.54,124.49
PA13
  Bottom 0.406: 157.48,124.49 163.83,124.49 163.83,123.22 165.1,123.22
PA14
  Bottom 0.406: 185.42,124.49 191.77,124.49 191.77,123.22 193.04,123.22
PA21
  Bottom 0.406: 101.6,121.95 107.95,121.95 107.95,120.68 109.22,120.68
PA22
  Bottom 0.406: 137.16,120.68 135.89,121.95 129.54,121.95
PA23
  Bottom 0.406: 157.48,121.95 163.83,121.95 163.83,120.68 165.1,120.68
PA24
  Bottom 0.406: 185.42,121.95 191.77,121.95 191.77,120.68 193.04,120.68
PA31
  Bottom 0.406: 101.6,119.41 107.95,119.41 107.95,118.14 109.22,118.14
PA32
  Bottom 0.406: 129.54,119.41 135.89,119.41 135.89,118.14 137.16,118.14
PA33
  Bottom 0.406: 157.48,119.41 163.83,119.41 163.83,118.14 165.1,118.14
PA34
  Bottom 0.406: 185.42,119.41 191.77,119.41 191.77,118.14 193.04,118.14
PA41
  Bottom 0.406: 101.6,114.33 107.95,114.33 107.95,115.6 109.22,115.6
PA42
  Bottom 0.406: 129.54,114.33 135.89,114.33 135.89,115.6 137.16,115.6
PA43
  Bottom 0.406: 157.48,114.33 163.83,114.33 163.83,115.6 165.1,115.6
PA44
  Bottom 0.406: 185.42,114.33 191.77,114.33 191.77,115.6 193.04,115.6
PA51
  Bottom 0.406: 101.6,111.79 107.95,111.79 107.95,113.06 109.22,113.06
PA52
  Bottom 0.406: 129.54,111.79 135.89,111.79 135.89,113.06 137.16,113.06
PA53
  Bottom 0.406: 157.48,111.79 163.83,111.79 163.83,113.06 165.1,113.06
PA54
  Bottom 0.406: 185.42,111.79 191.77,111.79 191.77,113.06 193.04,113.06
PA61
  Bottom 0.406: 101.6,109.25 107.95,109.25 107.95,110.52 109.22,110.52
PA62
  Bottom 0.406: 129.54,109.25 135.89,109.25 135.89,110.52 137.16,110.52
PA63
  Bottom 0.406: 157.48,109.25 163.83,109.25 163.83,110.52 165.1,110.52
PA64
  Bottom 0.406: 185.42,109.25 191.77,109.25 191.77,110.52 193.04,110.52
PA71
  Bottom 0.406: 101.6,106.71 107.95,106.71 107.95,107.98 109.22,107.98
PA72
  Bottom 0.406: 129.54,106.71 135.89,106.71 135.89,107.98 137.16,107.98
PA73
  Bottom 0.406: 157.48,106.71 163.83,106.71 163.83,107.98 165.1,107.98
PA74
  Bottom 0.406: 185.42,106.71 191.77,106.71 191.77,107.98 193.04,107.98
PB01
  Bottom 0.406: 86.36,124.49 99.06,124.49 100.33,125.76 106.68,125.76
PB02
  Bottom 0.406: 114.3,124.49 127,124.49 128.27,125.76 134.62,125.76
PB03
  Bottom 0.406: 142.24,124.49 154.94,124.49 156.21,125.76 162.56,125.76
PB04
  Bottom 0.406: 170.18,124.49 182.88,124.49 184.15,125.76 190.5,125.76
PB11
  Bottom 0.406: 86.36,121.95 99.06,121.95 100.33,123.22 106.68,123.22
PB12
  Bottom 0.406: 114.3,121.95 127,121.95 128.27,123.22 134.62,123.22
PB13
  Bottom 0.406: 142.24,121.95 154.94,121.95 156.21,123.22 162.56,123.22
PB14
  Bottom 0.406: 170.18,121.95 182.88,121.95 184.15,123.22 190.5,123.22
PB21
  Bottom 0.406: 86.36,119.41 99.06,119.41 100.33,120.68 106.68,120.68
PB22
  Bottom 0.406: 114.3,119.41 127,119.41 128.27,120.68 134.62,120.68
PB23
  Bottom 0.406: 142.24,119.41 154.94,119.41 156.21,120.68 162.56,120.68
PB24
  Bottom 0.406: 170.18,119.41 182.88,119.41 184.15,120.68 190.5,120.68
PB31
  Bottom 0.406: 86.36,116.87 99.06,116.87 100.33,118.14 106.68,118.14
PB32
  Bottom 0.406: 114.3,116.87 123.19,116.87 124.46,118.14 134.62,118.14
PB33
  Bottom 0.406: 142.24,116.87 151.13,116.87 152.4,118.14 162.56,118.14
PB34
  Bottom 0.406: 170.18,116.87 179.07,116.87 180.34,118.14 190.5,118.14
PB41
  Bottom 0.406: 86.36,114.33 99.06,114.33 100.33,115.6 106.68,115.6
PB42
  Bottom 0.406: 114.3,114.33 127,114.33 128.27,115.6 134.62,115.6
PB43
  Bottom 0.406: 142.24,114.33 154.94,114.33 156.21,115.6 162.56,115.6
PB44
  Bottom 0.406: 170.18,114.33 182.88,114.33 184.15,115.6 190.5,115.6
PB51
  Bottom 0.406: 86.36,111.79 99.06,111.79 100.33,113.06 106.68,113.06
PB52
  Bottom 0.406: 114.3,111.79 127,111.79 128.27,113.06 134.62,113.06
PB53
  Bottom 0.406: 142.24,111.79 154.94,111.79 156.21,113.06 162.56,113.06
PB54
  Bottom 0.406: 170.18,111.79 182.88,111.79 184.15,113.06 190.5,113.06
PB61
  Bottom 0.406: 86.36,109.25 99.06,109.25 100.33,110.52 106.68,110.52
PB62
  Bottom 0.406: 114.3,109.25 127,109.25 128.27,110.52 134.62,110.52
PB63
  Bottom 0.406: 142.24,109.25 154.94,109.25 156.21,110.52 162.56,110.52
PB64
  Bottom 0.406: 170.18,109.25 182.88,109.25 184.15,110.52 190.5,110.52
PB71
  Bottom 0.406: 86.36,106.71 99.06,106.71 100.33,107.98 106.68,107.98
PB72
  Bottom 0.406: 114.3,106.71 127,106.71 128.27,107.98 134.62,107.98
PB73
  Bottom 0.406: 142.24,106.71 154.94,106.71 156.21,107.98 162.56,107.98
PB74
  Bottom 0.406: 170.18,106.71 182.88,106.71 184.15,107.98 190.5,107.98
RD  (via drill 0.61 pad 1.02)
  Top 0.406: v101.6,38.13 101.6,33.05 102.87,31.78 104.14,31.78 | 104.14,30.51 104.14,31.78 | 55.88,53.37 55.88,48.29 57.15,47.02 v57.15,36.86 | 114.3,104.17 110.49,104.17 110.49,100.36 | 110.49,100.36 110.49,34.32 109.22,33.05 105.41,33.05 105.41,31.78 104.14,31.78 | 142.24,104.17 132.08,104.17 v132.08,102.9 | 170.18,104.17 166.37,104.17 166.37,38.13 163.83,38.13 163.83,33.05 162.56,31.78 160.02,31.78 160.02,30.51 | v104.14,102.9 105.41,101.63 105.41,100.36 110.49,100.36
  Bottom 0.406: 7.62,115.6 20.32,115.6 21.59,116.87 24.13,116.87 25.4,115.6 26.67,115.6 39.37,115.6 40.64,116.87 43.18,116.87 44.45,115.6 45.72,115.6 58.42,115.6 59.69,116.87 62.23,116.87 63.5,115.6 64.77,115.6 69.85,115.6 71.12,116.87 82.55,116.87 82.55,105.44 83.82,104.17 86.36,104.17 95.25,104.17 96.52,102.9 v104.14,102.9 | 104.14,30.51 116.84,30.51 118.11,29.24 153.67,29.24 154.94,30.51 160.02,30.51 | v101.6,38.13 90.17,38.13 85.09,38.13 83.82,36.86 v57.15,36.86 | v132.08,102.9 120.65,102.9 119.38,104.17 114.3,104.17
RESET  (via drill 0.61 pad 1.02)
  Top 0.406: 17.78,19.08 17.78,20.35 20.32,20.35 20.32,24.16 21.59,25.43 SIL1. | 39.37,78.77 39.37,77.5 41.91,77.5 43.18,76.23 43.18,53.37 43.18,48.29 44.45,47.02 44.45,31.78 43.18,30.51 43.18,19.08 27.94,19.08 26.67,20.35 26.67,29.24 | 104.14,58.45 104.14,77.5 v102.87,78.77
  Bottom 0.406: 104.14,58.45 113.03,58.45 114.3,57.18 153.67,57.18 154.94,58.45 160.02,58.45 | 26.67,29.24 25.4,29.24 25.4,30.51 22.86,30.51 22.86,29.24 SIL1. | 74.93,53.37 58.42,53.37 57.15,54.64 44.45,54.64 44.45,53.37 43.18,53.37 | 36.83,78.77 39.37,78.77 v102.87,78.77
RIA1
  Top 0.406: 119.38,35.59 120.65,36.86 120.65,77.5 121.92,78.77 124.46,78.77 124.46,80.04
RIA2
  Top 0.406: 175.26,35.59 180.34,35.59 180.34,64.8 181.61,66.07 181.61,78.77 180.34,78.77 180.34,80.04
RIB1
  Top 0.406: 104.14,38.13 106.68,38.13 106.68,80.04 105.41,81.31 96.52,81.31 96.52,80.04
RIB2
  Top 0.406: 160.02,38.13 161.29,39.4 161.29,77.5 160.02,78.77 152.4,78.77 152.4,80.04
RTSA1  (via drill 0.61 pad 1.02)
  Top 0.406: v128.27,50.83 128.27,71.15 127,71.15 127,72.42
  Bottom 0.406: 119.38,50.83 v128.27,50.83
RTSA2  (via drill 0.61 pad 1.02)
  Top 0.406: 175.26,50.83 173.99,52.1 v173.99,71.15
  Bottom 0.406: v173.99,71.15 181.61,71.15 181.61,72.42 182.88,72.42
RTSB1
  Top 0.406: 104.14,50.83 100.33,50.83 100.33,71.15 99.06,71.15 99.06,72.42
RTSB2
  Top 0.406: 160.02,50.83 156.21,50.83 156.21,71.15 154.94,71.15 154.94,72.42
RXDA1
  Top 0.406: 119.38,38.13 118.11,39.4 118.11,80.04 119.38,81.31 127,81.31 127,80.04
RXDA2  (via drill 0.61 pad 1.02)
  Top 0.406: v185.42,38.13 185.42,77.5 184.15,78.77 182.88,78.77 182.88,80.04
  Bottom 0.406: v185.42,38.13 175.26,38.13
RXDB1
  Top 0.406: 104.14,40.67 105.41,41.94 105.41,78.77 104.14,80.04 99.06,80.04
RXDB2  (via drill 0.61 pad 1.02)
  Top 0.406: v163.83,39.4 163.83,78.77 161.29,78.77 160.02,80.04 154.94,80.04
  Bottom 0.406: 160.02,40.67 161.29,40.67 162.56,39.4 v163.83,39.4
S$1
  Bottom 2.54: -1.27,3.84 -1.27,-1.24 5.08,-1.24
S$2
  Top 2.54: -1.27,3.84 -1.27,-1.24 5.08,-1.24
S$3
  Top 2.54: 5.08,152.43 -1.27,152.43 -1.27,146.08
S$4
  Bottom 2.54: 5.08,152.43 -1.27,152.43 -1.27,146.08
S$5
  Bottom 2.54: 194.31,152.43 200.66,152.43 200.66,146.08
S$6
  Top 2.54: 194.31,152.43 200.66,152.43 200.66,146.08
S$7
  Top 2.54: 200.66,5.11 200.66,-1.24 195.58,-1.24
S$8
  Bottom 2.54: 200.66,5.11 200.66,-1.24 195.58,-1.24
TXDA1  (via drill 0.61 pad 1.02)
  Top 0.406: v130.81,45.75 130.81,92.74 128.27,92.74 128.27,78.77 127,78.77 127,77.5
  Bottom 0.406: 119.38,45.75 v130.81,45.75
TXDA2  (via drill 0.61 pad 1.02)
  Top 0.406: v181.61,45.75 181.61,57.18 184.15,57.18 184.15,76.23 182.88,76.23 182.88,77.5
  Bottom 0.406: v181.61,45.75 175.26,45.75
TXDB1  (via drill 0.61 pad 1.02)
  Top 0.406: 104.14,45.75 102.87,44.48 102.87,36.86 107.95,36.86 v107.95,77.5
  Bottom 0.406: v107.95,77.5 99.06,77.5
TXDB2  (via drill 0.61 pad 1.02)
  Top 0.406: 160.02,45.75 158.75,44.48 158.75,36.86 162.56,36.86 v162.56,77.5
  Bottom 0.406: v162.56,77.5 154.94,77.5
WAIT
  Top 0.406: 36.83,29.24 36.83,62.26 38.1,63.53 38.1,80.04 48.26,80.04 48.26,53.37
WI2
  Top 0.406: 58.42,19.08 57.15,20.35 57.15,27.97 58.42,27.97 58.42,29.24
WI3
  Bottom 0.406: 22.86,15.27 26.67,15.27 26.67,21.62 58.42,21.62
WI5
  Top 0.406: 58.42,16.54 55.88,16.54 55.88,27.97 54.61,29.24 54.61,31.78
WI6
  Top 0.406: 54.61,26.7 R3. 54.61,14 58.42,14
WI7
  Top 0.406: R4. 69.85,26.7
  Bottom 0.406: 69.85,26.7 66.04,26.7
WI8
  Top 0.406: 66.04,24.16 68.58,24.16 68.58,27.97 69.85,29.24 69.85,31.78
WR  (via drill 0.61 pad 1.02)
  Top 0.406: 53.34,53.37 53.34,85.12 54.61,86.39 57.15,86.39 57.15,91.47 | 38.1,91.47 v38.1,88.93
  Bottom 0.406: 38.1,91.47 46.99,91.47 48.26,92.74 BR3A. 55.88,91.47 57.15,91.47 | 19.05,91.47 20.32,91.47 20.32,88.93 v38.1,88.93 73.66,88.93 74.93,90.2 74.93,91.47 76.2,91.47
WR_1  (via drill 0.61 pad 1.02)
  Top 0.406: v16.51,102.9 16.51,94.01
  Bottom 0.406: 16.51,94.01 19.05,94.01 | 7.62,102.9 v16.51,102.9
WR_2  (via drill 0.61 pad 1.02)
  Top 0.406: 35.56,94.01 v35.56,104.17
  Bottom 0.406: 35.56,94.01 38.1,94.01 | 26.67,102.9 27.94,102.9 29.21,104.17 v35.56,104.17
WR_3
  Top 0.406: 45.72,102.9 48.26,102.9 48.26,92.74 54.61,92.74 54.61,94.01
  Bottom 0.406: 54.61,94.01 57.15,94.01
WR_4
  Top 0.406: 64.77,102.9 66.04,101.63 66.04,94.01 67.31,92.74 73.66,92.74 73.66,94.01
  Bottom 0.406: 73.66,94.01 76.2,94.01
ZC/TO0  (via drill 0.61 pad 1.02)
  Top 0.406: 175.26,40.67 175.26,43.21 | v83.82,40.67 v83.82,77.5 | 119.38,43.21 119.38,40.67
  Bottom 0.406: 119.38,43.21 114.3,43.21 113.03,41.94 102.87,41.94 101.6,40.67 90.17,40.67 v83.82,40.67 | v83.82,77.5 71.12,77.5 | 175.26,40.67 162.56,40.67 161.29,41.94 125.73,41.94 124.46,40.67 119.38,40.67
ZC/TO1  (via drill 0.61 pad 1.02)
  Top 0.406: 68.58,80.04 64.77,80.04 v64.77,44.48
  Bottom 0.406: 160.02,43.21 121.92,43.21 120.65,44.48 110.49,44.48 109.22,43.21 104.14,43.21 90.17,43.21 85.09,43.21 83.82,44.48 v64.77,44.48
ZC/TO2  (via drill 0.61 pad 1.02)
  Top 0.406: 90.17,45.75 88.9,47.02 v88.9,80.04
  Bottom 0.406: v88.9,80.04 71.12,80.04